# Keil uVision project ADC_DMA_Injected.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ADC_DMA_Injected
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,MAINCLK_FREQ_96MHz
  c include: ..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CMSIS\Device\WB\WB32F10x;..\..\..\..\Libraries\WB32F10x_StdPeriph_Driver\inc;..\..\..\WB32F10x_StdPeriph_Template;..\..\..\..\Utilities\Common
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group CMSIS
    ../../../../Libraries/CMSIS/Device/WB/WB32F10x/startup/arm/: startup_wb32f10x.s
    ../../../../Libraries/CMSIS/Device/WB/WB32F10x/: system_wb32f10x.c
  group User
    ./: main.c
    ../../../../Utilities/Common/: bsp_uart1.c Retarget_uart1.c
  group StdPeriph_Driver
    ../../../../Libraries/WB32F10x_StdPeriph_Driver/src/: misc.c wb32f10x_adc.c wb32f10x_anctl.c wb32f10x_dmac.c wb32f10x_gpio.c wb32f10x_pwr.c wb32f10x_rcc.c
